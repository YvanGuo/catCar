# Keil uVision project IO-LED.uvproj, settings and files
target catCar (MCS-51)
  device: R80515 Core CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 MDU_R515
  output: catCar +hex
  c flags: Optimize=9 SizeSpeed=1
  group app
    ./: main.c
  group hal
    ./hal/: carCtl.c ir.c motor.c pinCtl.c servoCommon.c tailCtl.c wifi.c timer.c serial.c
  group driver
    ./driver/wifi/esp8266/: wifi_esp8266.c
    ./driver/51/: hw_gpioCtl51.c hw_pwm.c hw_serial.c hw_timer.c
  group core
    ./core/51/: delay.c
